PLATFORM = "talos"
PBT_BUILD_DATE = "260224.1"

require common.inc

SRC_URI[camxlib.sha256sum]     = "263a9f4f1ac609bd51ad8af92a47da9ea7b9be844a45a5f4b4d741e0bfebf5a9"
SRC_URI[camx.sha256sum]        = "47b3996ec1ba386877aa1de6519ba68084d4da7f47958fe64569c0a3011f4bcd"
SRC_URI[chicdk.sha256sum]      = "730341ba1d1d505d8493eff1cc5cdbfa07f266ecb57fe39017bba16cf66f7cd3"
SRC_URI[camxcommon.sha256sum]  = "2c019c4d07d1e9927ce1dc641cd90940a3e3a90464cd1d5b79ae7e63b0e37b79"
