require firmware-qcom-boot-qcs9100.inc

SRC_URI[bootbinaries.sha256sum] = "f19724eab9571b97087933b60a0b75246537fda5ef75a97e6d5dee4020ef59a2"
