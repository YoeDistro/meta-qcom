require firmware-qcom-boot-qcs6490.inc

SRC_URI[bootbinaries.sha256sum] = "ad5434f1afd2f801e63266d75c97425d1fea22b2edc67b6f5a0f472ca55844ed"
