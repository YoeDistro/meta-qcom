require firmware-qcom-boot-qcs8300.inc

SRC_URI[bootbinaries.sha256sum] = "e7a22f9a7ddae92e6e307afdd9f06608ddd3b0ac7f2e4994bacfb51729e8337f"
