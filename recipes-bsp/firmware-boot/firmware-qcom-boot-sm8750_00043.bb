require firmware-qcom-boot-sm8750.inc

SRC_URI[bootbinaries.sha256sum] = "e56b8cb82fd2566b9de9ca771e342dd7559bbfb51c94587a65c4ae395f605805"
